# Keil uVision project demo_N76E003.uvproj, settings and files
target PWR_Trans_NU (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: demo_N76E003 +hex
  c flags: Optimize=7 SizeSpeed=1
  c include: .\Common;.\include;.\system;.\user;.\hardware\LED;.\hardware\adc;.\hardware\wdt;.\hardware\delay;.\hardware\sleep;.\hardware\uart1;.\hardware\halfduplex;.\hardware\motor;.\hardware\ppm;.\hardware;.\hardware\i2c_simu;.\hardware\st7032_i2c
  group user
    ./user/: main.c
  group hardware
    ./hardware/LED/: led.c
    ./hardware/wdt/: wdt.c
    ./hardware/delay/: delay.c
    ./hardware/adc/: adc.c
    ./hardware/ppm/: ppm.c
    ./hardware/motor/: motor.c
    ./hardware/i2c_simu/: i2c_simu.c
    ./hardware/st7032_i2c/: st7032_i2c.c
  group system
    ./system/: sys_tim.c
    ./Common/: Common.c
  group uart
    ./hardware/uart1/: uart1.c
  group startup
    ./Startup/: STARTUP.A51
